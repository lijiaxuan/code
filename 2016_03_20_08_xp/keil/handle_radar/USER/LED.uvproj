# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,RADAR,GPS_ENABLE,LEFT
  c misc: --c99
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\steering;..\SYSTEM\delay;code
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group control
    ./code/control/: main.c
  group module
    ./code/module/radar/src/: radar.c radar_global.c
    ./code/module/steer/src/: steer.c steer_global.c
    ./code/module/infrared/src/: infrared_global.c infrared.c
    ./code/module/bluetooth/src/: bluetooth.c bluetooth_global.c
  group driver
    ../STM32F10x_FWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
    ./code/driver/delay/src/: delay.c
    ./code/driver/can/src/: can.c
  group other
    ./: system_stm32f10x.c system_stm32f10x.h stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h stm32f10x.h
    ../CORE/: startup_stm32f10x_hd.s
    ../STM32F10x_FWLib/src/: stm32f10x_can.c
