# Keil uVision project LED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\steering;..\SYSTEM\delay;E:\handle\USER\code
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group control
    ./code/control/: main.c
    ./code/control/handle_control/inc/: handle_control.h handle_control_global_variable.h handle_control_struct.h
    ./code/control/handle_control/src/: handle_control.c handle_control_global_variable.c
  group module
    ./code/module/handle/inc/: handle.h handle_global_variable.h handle_struct.h
    ./code/module/handle/src/: handle.c handle_global_variable.c
  group driver
    ./code/driver/delay/inc/: delay.h
    ./code/driver/delay/src/: delay.c
    ./code/driver/pwm/inc/: pwm.h
    ./code/driver/pwm/src/: pwm.c
    ./code/driver/usart/inc/: usart.h
    ./code/driver/usart/src/: usart.c
    ../STM32F10x_FWLib/src/: stm32f10x_usart.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c misc.c
  group other
    ./: system_stm32f10x.c system_stm32f10x.h stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h stm32f10x.h
    ../CORE/: startup_stm32f10x_hd.s
